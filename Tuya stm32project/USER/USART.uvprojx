# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\TUYA;..\HARDWARE\03WTC;..\SYSTEM\rtc;..\HARDWARE\SHT31;..\SYSTEM\iic;..\SYSTEM\adc;..\HARDWARE\LOGIC;..\SYSTEM\tim;..\HARDWARE\BLE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/03WTC/: 03WTC.c
    ../HARDWARE/SHT31/: SHT31.c
    ../HARDWARE/LOGIC/: logic.c
    ../HARDWARE/BLE/: ble.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/rtc/: rtc.c
    ../SYSTEM/iic/: iic.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/tim/: tim.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group TUYA
    ../TUYA/: mcu_api.c protocol.c system.c
software components: Data Exchange:JSON:Jansson 2.7.0
